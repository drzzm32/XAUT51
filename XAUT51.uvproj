# Keil uVision project XAUT51.uvproj, settings and files
target Target (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: XAUT51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: LCD.c main.c util.c
  group Header
    ./: LCD.h STC89.h util.h HARD.h
